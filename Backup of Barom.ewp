# IAR project Backup of Barom.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x8 ST STM32F100x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; app\; board\; modules\; ..\library\CMSIS\Core\CM3\; ..\library\STM32F10x_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: BAROM.out
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: bmp085.c calculations.c dac.c delays.c ds18b20.c hd44780_driver.c i2c.c ioconfig.c LCD.c main.c RTC.c sht1x.c timers.c uart.c
  group CMSIS
    ../library/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_md_vl.s
    ../library/CMSIS/Core/CM3/: system_stm32f10x.c
  group Module
    modules/: drv_hd44780.c drv_hd44780_cnfg.h drv_hd44780_l.c
  group Other
    ./: readme.txt
    config/: STM32F10x_FLASH.icf
  group StdPeriph_Driver
    app/: clock_calendar.c
    ../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Vectors
    app/: stm32f10x_it.c
